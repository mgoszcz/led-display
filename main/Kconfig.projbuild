## main/Kconfig.projbuild
```kconfig
menu "LED Display Configuration"

    config WIFI_MAX_RETRY
        int "WiFi maximum retry count"
        default 5
        range 0 20

endmenu
```
